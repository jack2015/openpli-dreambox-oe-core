MODULE = "AnalogClock"
SUMMARY = "permanent analog clock on the screen"
DESCRIPTION = "permanent analog clock on the screen"

require conf/license/license-gplv2.inc

require openplugins-replace-pli.inc

require openplugins-distutils.inc
