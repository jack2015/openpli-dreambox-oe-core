MODULE = "SetPicon"
SUMMARY = "Work with services picons"
DESCRIPTION = "Work with services picons"

require conf/license/license-gplv2.inc
require openplugins-replace-pli.inc
require openplugins-distutils.inc
