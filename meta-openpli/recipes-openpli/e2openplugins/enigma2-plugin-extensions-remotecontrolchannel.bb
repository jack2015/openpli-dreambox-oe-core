MODULE = "RemoteControlChannel"
SUMMARY = "Remote control ir channel selection"
DESCRIPTION = "Remote control ir channel selection"

require conf/license/license-gplv2.inc
require openplugins-replace-pli.inc
require openplugins-distutils.inc
