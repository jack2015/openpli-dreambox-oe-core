MODULE = "MeteoViewer"
SUMMARY = "meteo pictures viewer"
DESCRIPTION = "meteo pictures viewer"

require conf/license/license-gplv2.inc
require openplugins-replace-pli.inc
require openplugins-distutils.inc
