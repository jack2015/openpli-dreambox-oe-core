MODULE = "PermanentVfdClock"
SUMMARY = "Show clock in VFD permanently"
DESCRIPTION = "Show clock in VFD permanently"

PR="r0"

require conf/license/license-gplv2.inc
require openplugins-replace-pli.inc
require openplugins-distutils.inc
