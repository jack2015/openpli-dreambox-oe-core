# my line
PACKAGECONFIG_remove = "gnutls"
PACKAGECONFIG_append = " openssl"
