# Just a comment line to avoid PAK archive (application/x-pak)
PACKAGECONFIG_remove = "gnutls"
PACKAGECONFIG_append = " openssl"
PACKAGE_NO_LOCALE = "1"
