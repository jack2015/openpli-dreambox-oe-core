# Just a comment line to avoid PAK archive (application/x-pak)
PACKAGECONFIG = "openssl"

PACKAGE_NO_LOCALE = "1"
