EXTRA_OECONF_append = " --disable-werror"
RPROVIDES_${PN}_append = " libcrypt1 libcrypt.so.1 libcrypt.so.1.1.0 libowcrypt.so.1"
