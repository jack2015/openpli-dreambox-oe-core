#
EXTRA_OECONF_append = " --disable-werror"
