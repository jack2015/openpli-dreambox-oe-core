FILES:${PN}-dbg += "\
    ${libdir}/enigma2/python/*.debug \
    ${libdir}/enigma2/python/*/*.debug \
    ${libdir}/enigma2/python/*/*/*.debug \
    ${libdir}/enigma2/python/*/*/*/*.debug \
    ${libdir}/enigma2/python/*/*/*/*/*.debug \
    ${libdir}/enigma2/python/*/*/*/*/*/*.debug \
    ${libdir}/enigma2/python/*/*/*/*/*/*/*.debug \
    ${libdir}/enigma2/python/*/*/*/*/*/*/*/*.debug \
    ${libdir}/enigma2/python/*/*/*/*/*/*/*/*/*.debug \
    ${libdir}/enigma2/python/*/*/*/*/*/*/*/*/*/*.debug \
    "

FILES:${PN}-src += "\
    ${libdir}/enigma2/python/*.py \
    ${libdir}/enigma2/python/*/*.py \
    ${libdir}/enigma2/python/*/*/*.py \
    ${libdir}/enigma2/python/*/*/*/*.py \
    ${libdir}/enigma2/python/*/*/*/*/*.py \
    ${libdir}/enigma2/python/*/*/*/*/*/*.py \
    ${libdir}/enigma2/python/*/*/*/*/*/*/*.py \
    ${libdir}/enigma2/python/*/*/*/*/*/*/*/*.py \
    ${libdir}/enigma2/python/*/*/*/*/*/*/*/*/*.py \
    ${libdir}/enigma2/python/*/*/*/*/*/*/*/*/*/*.py \
    "
