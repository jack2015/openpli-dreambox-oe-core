RDEPENDS_${PN}-client = "rpcbind"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
