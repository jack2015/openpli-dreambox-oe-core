RDEPENDS_${PN} = "kernel-module-cifs"

CFLAGS_append_sh4 += " -std=gnu99"
