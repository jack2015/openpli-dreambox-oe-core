RPROVIDES_${PN}_append = " libusb-0.1-4"
