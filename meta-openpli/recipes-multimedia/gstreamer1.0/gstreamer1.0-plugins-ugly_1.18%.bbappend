#
PACKAGECONFIG = "${GSTREAMER_ORC} a52dec mpeg2dec cdio dvdread amrnb amrwb"
PACKAGE_NO_LOCALE = "1"
