#
PACKAGECONFIG = "${GSTREAMER_ORC} amrnb amrwb a52dec mpeg2dec cdio dvdread"
PACKAGE_NO_LOCALE = "1"
