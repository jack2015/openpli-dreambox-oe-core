SRCREV = "${AUTOREV}"
X264_DISABLE_ASM = "--disable-asm"
