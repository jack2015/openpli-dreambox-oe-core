RDEPENDS_${PN} += " libltdl"
