SRC_URI = "git://github.com/OpenELEC/libsquish.git;protocol=${GIT_PROTOCOL}"
