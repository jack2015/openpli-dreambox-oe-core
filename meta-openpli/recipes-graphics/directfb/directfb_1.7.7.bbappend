BBCLASSEXTEND = "native"
PACKAGE_ARCH := "${MACHINE_ARCH}"
