RDEPENDS_${PN}_class-target_remove = "cpp cpp-symlinks"
RDEPENDS_${PN}_remove =  "cpp cpp-symlinks"
include python-package-split.inc
