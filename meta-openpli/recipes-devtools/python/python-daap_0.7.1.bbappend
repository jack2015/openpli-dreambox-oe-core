# top line
SRC_URI += " \
	file://python-daap.patch \
"
