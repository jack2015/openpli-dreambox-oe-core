SRC_URI_append = " file://receive_timeout.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
