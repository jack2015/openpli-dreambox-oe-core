# ORIGINAL DM800SE
SRC_URI = "https://jack2015.github.io/basefile/secondstage-dm800se-84-original.zip"
SRC_URI[md5sum] = "d1bf0db47ec9a07cdaf89ae171a3bc77"
SRC_URI[sha256sum] = "ab66b040229caf675cb10d9202e6e9ec255df3ac66fc42c4a1d4561d70123e35"
