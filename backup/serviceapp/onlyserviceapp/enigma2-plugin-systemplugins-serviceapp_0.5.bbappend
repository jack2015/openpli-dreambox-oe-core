RRECOMMENDS_${PN} = "exteplayer3"

SRC_URI = "git://github.com/jack2015/serviceapp.git;branch=develop"
