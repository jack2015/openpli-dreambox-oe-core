# CLONE DM500HD
SRC_URI = "https://jack2015.github.io/basefile/dreambox-dvb-modules-dm500hd-3.2-dm500hd-20140616-clone.tar.bz2;name=modules \
	file://modules"
SRC_URI[modules.md5sum] = "12e674ce8e89d7d8705d6c7e867c2303"
SRC_URI[modules.sha256sum] = "573cc3f08e29dba0852171b183013631f9a6a22afb14a20f64ed125d93735ecb"
