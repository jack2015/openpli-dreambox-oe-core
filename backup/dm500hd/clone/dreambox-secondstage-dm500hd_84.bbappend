# CLONE DM500HD
SRC_URI = "https://jack2015.github.io/basefile/secondstage-dm500hd-84-clone.zip"
SRC_URI[md5sum] = "52d1bff5dec7de7196ecb449e215f394"
SRC_URI[sha256sum] = "554a6c92b794784e937d982ad347990007009df97b34fdcbe2918f2834134821"
