SRC_URI[dm520.md5sum] = "b9f5ef35dee346d8feb0f0abeace057f"
SRC_URI[dm520.sha256sum] = "a78a5a78afd7b7d8c6e8fc9e993e4084d613988a3c291bbeaa8d88841af7fa8b"
SRC_URI = "https://jack2015.github.io/basefile/dreambox-secondstage_3_dm520-clone.tar.xz;name=${MACHINE}"
S = "${WORKDIR}/dreambox-secondstage_3_dm520"
