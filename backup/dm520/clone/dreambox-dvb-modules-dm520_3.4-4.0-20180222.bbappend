SRC_URI[dm520.md5sum] = "303ce923be93cb54b0c25527a658d22f"
SRC_URI[dm520.sha256sum] = "778397f559eade1f241a29e23a485bbbbf45c4a206e44e7b36318cd348be734d"
SRC_URI = "https://jack2015.github.io/basefile/dreambox-dvb-modules_3.4-4.0-dm520-20180222_dm520-clone.tar.xz;name=${MACHINE}"
S = "${WORKDIR}/dreambox-dvb-modules_3.4-4.0-dm520-20180222_dm520"
