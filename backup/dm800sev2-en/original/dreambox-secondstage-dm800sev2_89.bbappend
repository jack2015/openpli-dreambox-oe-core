# ORIGINAL DM800SEV2
SRC_URI = "https://jack2015.github.io/basefile/secondstage-dm800sev2-89-original.tar.bz2"

SRC_URI[md5sum] = "ed2789cc6b3b9ebcfa498e70f856058b"
SRC_URI[sha256sum] = "6dd57e2e5f25ecd173701bce112ceeb1763f52a822c5ce25f82afd33d5e2c82b"
