SRC_URI:remove = "git://chromium.googlesource.com/webm/libvpx;protocol=https"
SRC_URI:append = "git://github.com/webmproject/libvpx.git;protocol=git"
