RDEPENDS_${PN}_remove = "wget"
