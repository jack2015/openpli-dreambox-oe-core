SUMMARY:enigma2-plugin-extensions-aihdcontroler = "Ai.HD skins Control"
SUMMARY:enigma2-plugin-extensions-antiscrollbar = "overlay for scrollbars on your tvscreen"
SUMMARY:enigma2-plugin-extensions-audiosync = "Set Audio delay"
SUMMARY:enigma2-plugin-extensions-automaticcleanup = "Automatic System Cleanup (setting backups, orphaned movie files, timer entries)"
SUMMARY:enigma2-plugin-extensions-automaticvolumeadjustment = "Automatic Volume Adjustment"
SUMMARY:enigma2-plugin-extensions-autoresolution = "Automatically change resolution"
SUMMARY:enigma2-plugin-extensions-autotimer = "Automatically add Timers based on simple rules"
SUMMARY:enigma2-plugin-extensions-babelzapper = "Control your dreambox with only the MUTE button"
SUMMARY:enigma2-plugin-extensions-blindscan = "satelite blind scan"
SUMMARY:enigma2-plugin-extensions-bonjour = "Bonjour/avahi-daemon management for your Dreambox"
SUMMARY:enigma2-plugin-extensions-cdinfo = "read audio CD-Text or query CDDB for album and track info"
SUMMARY:enigma2-plugin-extensions-dreamexplorer = "DreamExplorer: manage files on your box"
SUMMARY:enigma2-plugin-extensions-dreamirc = "simple IRC GroupChat client for e2"
SUMMARY:enigma2-plugin-extensions-dreammediathek = "Play rtp Stream on your Dreambox"
SUMMARY:enigma2-plugin-extensions-dvdbackup = "Create a backup of your Video-DVD"
SUMMARY:enigma2-plugin-extensions-dyndns = "a client for www.dyndns.org"
SUMMARY:enigma2-plugin-extensions-easyinfo = "You can use the EasyInfo for manage your EPG plugins from info button. "
SUMMARY:enigma2-plugin-extensions-easymedia = "Start easy your multimedia plugins with the PVR-button."
SUMMARY:enigma2-plugin-extensions-eibox = "graphical European Installation Bus visualization"
SUMMARY:enigma2-plugin-extensions-elektro = "Automatically shuts down the Dreambox to deep standby (Power Save Mode)"
SUMMARY:enigma2-plugin-extensions-emailclient = "a imap4 client to access imap accounts and read emails"
SUMMARY:enigma2-plugin-extensions-epgrefresh = "Plugin to refresh EPG Data when Receiver is inactive"
SUMMARY:enigma2-plugin-extensions-epgsearch = "search the epg and list results"
SUMMARY:enigma2-plugin-extensions-fancontrol2 = "Temperature dependent fan control"
SUMMARY:enigma2-plugin-extensions-filebrowser = "manage local Files"
SUMMARY:enigma2-plugin-extensions-fritzcall = "Show Incoming and Outgoing Calls on your TV Screen with a Fritz!Box"
SUMMARY:enigma2-plugin-extensions-fstabeditor = "Editor for fstab"
SUMMARY:enigma2-plugin-extensions-ftpbrowser = "FTP-Browser-Plugin for Enigma2"
SUMMARY:enigma2-plugin-extensions-growlee = "redirect notifications to growl"
SUMMARY:enigma2-plugin-extensions-httpproxy = "use your Dreambox as Web Proxy"
SUMMARY:enigma2-plugin-extensions-imdb = "query movie details from the Internet Movie Database"
SUMMARY:enigma2-plugin-extensions-kiddytimer = "Allows to control the Kids' daily TV usage"
SUMMARY:enigma2-plugin-extensions-letterbox = "Zoom into letterboxed/anamorph movies"
SUMMARY:enigma2-plugin-extensions-logomanager = "manage logos to display at boottime/radiomode/reboot/restart gui"
SUMMARY:enigma2-plugin-extensions-mediadownloader = "Media File Downloader Plugin for Enigma2"
SUMMARY:enigma2-plugin-extensions-merlinepg = "Merlin Programm Guide"
SUMMARY:enigma2-plugin-extensions-merlinepgcenter = "MerlinEPGCenter: more than just an EPG..."
SUMMARY:enigma2-plugin-extensions-merlinmusicplayer = "Merlin Music Player and iDream (music management)"
SUMMARY:enigma2-plugin-extensions-mosaic = "Shows you screenshots of the services in a selected bouquet"
SUMMARY:enigma2-plugin-extensions-moviecut = "Perform the cuts specified with the Cutlist editor"
SUMMARY:enigma2-plugin-extensions-movieretitle = "Change the filename, title, description and location of a movie"
SUMMARY:enigma2-plugin-extensions-movietagger = "Add tags to recorded movies, to sort a large list of movies"
SUMMARY:enigma2-plugin-extensions-mphelp = "reusable help component"
SUMMARY:enigma2-plugin-extensions-multirc = "Use multiple Dreamboxes with different RCs"
SUMMARY:enigma2-plugin-extensions-ncidclient = "Show Incoming Calls on your TV Screen using any NCID server (e.g. VF EasyBox)"
SUMMARY:enigma2-plugin-extensions-networkbrowser = "Networkbrowser and Network-Mountmanager"
SUMMARY:enigma2-plugin-extensions-ofdb = "query movie details from the Online Film Datenbank"
SUMMARY:enigma2-plugin-extensions-orfat = "Streaming modules for the orf.at web page"
SUMMARY:enigma2-plugin-extensions-orfteletext = "Browse ORF and SAT1 Teletext independent from channel. This need I-net conection."
SUMMARY:enigma2-plugin-extensions-partnerbox = "Partnerbox (Remote Timer and Remote TV Player)"
SUMMARY:enigma2-plugin-extensions-permanentclock = "Shows the clock permanent on the screen"
SUMMARY:enigma2-plugin-extensions-porncenter = "Adult streaming plugin."
SUMMARY:enigma2-plugin-extensions-primetimemanager = "Prime Time Manager for timers"
SUMMARY:enigma2-plugin-extensions-reconstructapsc = "Reconstruct missing or corrupt .ap and .sc files of movies"
SUMMARY:enigma2-plugin-extensions-recordinfobar = "record infobar addon for enigma2 box"
SUMMARY:enigma2-plugin-extensions-satipclient = "SAT>IP Client attached to vtuner"
SUMMARY:enigma2-plugin-extensions-seekbar = "Replaces the minute input screen for seek functions"
SUMMARY:enigma2-plugin-extensions-setpasswd = "change or reset root password on your dreambox"
SUMMARY:enigma2-plugin-extensions-shoutcast = "A client to listen and record SHOUTcast internet radio"
SUMMARY:enigma2-plugin-extensions-showclock = "Push key 'Exit long' to show the clock while watching TV"
SUMMARY:enigma2-plugin-extensions-simplerss = "rss viewer for the enigma2 gui"
SUMMARY:enigma2-plugin-extensions-svdrp = "basic remote control server using svdrp"
SUMMARY:enigma2-plugin-extensions-systemtime = "Change system time in enigma2 box"
SUMMARY:enigma2-plugin-extensions-tageditor = "Edit tags of movies, and in timers"
SUMMARY:enigma2-plugin-extensions-trafficinfo = "Show German traffic jams"
SUMMARY:enigma2-plugin-extensions-transcodingsetup = "Use this plugin to configure default values for transcoding."
SUMMARY:enigma2-plugin-extensions-transmission = "Bittorrent client for enigma2"
SUMMARY:enigma2-plugin-extensions-terrestrialscan = "Terrestrial Scan selects the strongest transponders where there are duplicates."
SUMMARY:enigma2-plugin-extensions-tvcharts = "Generates and Shows TV Charts of all users having this plugin installed."
SUMMARY:enigma2-plugin-extensions-unwetterinfo = "UnwetterInfo shows German storm information."
SUMMARY:enigma2-plugin-extensions-valixdcontrol = "Customize Vali-XD skins by yourself."
SUMMARY:enigma2-plugin-extensions-virtualzap = "See service-epg (and PiP) from other channels in an infobar."
SUMMARY:enigma2-plugin-extensions-vlcplayer = "Play AVI/DIVX/WMV... videos from PC on your Dreambox.Needs a running VLC on your pc."
SUMMARY:enigma2-plugin-extensions-vps = "The VPS-Plugin can determine whether a programme begins earlier or lasts longer."
SUMMARY:enigma2-plugin-extensions-vfdcontrol = "control 7 segment VFD display"
SUMMARY:enigma2-plugin-extensions-weatherplugin = "WeatherPlugin shows weatherforecasts on your Dreambox."
SUMMARY:enigma2-plugin-extensions-webcamviewer = "With WebcamViewer you can watch webcams on your TV Screen."
SUMMARY:enigma2-plugin-extensions-werbezapper = "With Werbezapper you can bridge commercials by creating short timers."
SUMMARY:enigma2-plugin-extensions-zaphistorybrowser = "Shows a list containing the zapping-history and allows user to zap to the entries or to modify them."
SUMMARY:enigma2-plugin-extensions-zapstatistic = "ZapStatistic shows the watched services with some statistics."
SUMMARY:enigma2-plugin-extensions-zdfmediathek = "ZDFMediathek allows you to watch streams from ZDF Mediathek."

RDEPENDS:enigma2-plugin-extensions-cdinfo = "cdtextinfo kernel-module-isofs"
RDEPENDS:enigma2-plugin-extensions-dreammediathek = "python-twisted-web"
RDEPENDS:enigma2-plugin-extensions-dvdbackup = "cdrkit libdvdread dvdbackup"
RDEPENDS:enigma2-plugin-extensions-emailclient = "python-twisted-web python-twisted-mail python-email python-pyopenssl python-shell python-textutils"
RDEPENDS:enigma2-plugin-extensions-epgrefresh = "python-codecs python-lang python-xml enigma2-plugin-systemplugins-mphelp"
RDEPENDS:enigma2-plugin-extensions-fritzcall = "python-twisted-web python-html python-textutils"
RDEPENDS:enigma2-plugin-extensions-ftpbrowser = "python-twisted-protocols python-shell enigma2-plugin-systemplugins-toolkit"
RDEPENDS:enigma2-plugin-extensions-growlee = "python-twisted-protocols python-netclient python-crypt python-re python-threading python-lang"
RDEPENDS:enigma2-plugin-extensions-httpproxy = "python-twisted-web"
RDEPENDS:enigma2-plugin-extensions-imdb = "python-html python-twisted-web enigma2-plugin-systemplugins-toolkit"
RDEPENDS:enigma2-plugin-extensions-logomanager = "enigma2-plugin-extensions-filebrowser"
RDEPENDS:enigma2-plugin-extensions-mediadownloader = "python-twisted-web python-netclient python-shell"
RDEPENDS:enigma2-plugin-extensions-merlinmusicplayer = "python-twisted-web python-mutagen python-sqlite3"
RDEPENDS:enigma2-plugin-extensions-ncidclient = "python-twisted-web python-html python-textutils"
RDEPENDS:enigma2-plugin-extensions-ofdb = "python-html python-twisted-web"
RDEPENDS:enigma2-plugin-extensions-orfat = "enigma2-plugin-extensions-vlcplayer python-twisted-web"
RDEPENDS:enigma2-plugin-extensions-partnerbox = "python-twisted-web"
RDEPENDS:enigma2-plugin-extensions-shoutcast = "python-twisted-web streamripper"
RDEPENDS:enigma2-plugin-extensions-simplerss = "python-twisted-web python-codecs python-xml enigma2-plugin-extensions-mediadownloader enigma2-plugin-systemplugins-toolkit"
RDEPENDS:enigma2-plugin-extensions-svdrp = "python-twisted-protocols"
RDEPENDS:enigma2-plugin-extensions-teletext = "enigma2-plugin-systemplugins-toolkit"
RDEPENDS:enigma2-plugin-extensions-trafficinfo = "python-twisted-web"
RDEPENDS:enigma2-plugin-extensions-transmission = "transmission transmission-client"
RDEPENDS:enigma2-plugin-extensions-tvcharts = "python-twisted-web"
RDEPENDS:enigma2-plugin-extensions-unwetterinfo = "python-twisted-web"
RDEPENDS:enigma2-plugin-extensions-webcamviewer = "python-twisted-web python-shell"
RDEPENDS:enigma2-plugin-extensions-zdfmediathek = "python-html python-twisted-web"
RDEPENDS:enigma2-plugin-systemplugins-mphelp = "python-xml"
# RDEPENDS:enigma2-plugin-systemplugins-systemtime = "ntpdate"
RDEPENDS:enigma2-plugin-systemplugins-toolkit = "python-twisted-core python-threading python-html python-re"
