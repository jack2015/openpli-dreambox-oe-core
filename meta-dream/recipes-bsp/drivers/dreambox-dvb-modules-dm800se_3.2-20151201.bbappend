# ORIGINAL DM800SE
SRC_URI = "https://jack2015.github.io/basefile/dreambox-dvb-modules-dm800se-3.2-dm800se-20151201-original.tar.bz2;name=modules \
	file://modules"
SRC_URI[modules.md5sum] = "46d4c11fb3704a70ae57b1f0dadfd6de"
SRC_URI[modules.sha256sum] = "f34897dd856e50bbd8fb7df203d649230da2b3040713f7a6c882f306bcb4e8db"

